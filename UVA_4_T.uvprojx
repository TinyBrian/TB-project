# Keil uVision project UVA_4_T.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UVA_4_T +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F1
  c include: .\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\src;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APPs;.\Modules;.\Math;.\core\driver\include;.\core\driver\eMPL;.\core\driver\stm32L;.\core\mllite;.\core\eMPL-hal;.\core\mpl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Users
    ./: main.c stm32f4xx_it.c
    ./APPs/: Type_Define_self.h
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40xx.s
  group Drivers
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group APPs
    ./APPs/: UART_init.c ADC_init.c EXIT_init.c IIC_init.c MSysTick.c PWM_TIMx_init.c Delay.c LED.c Motor.c Bit_ADDR.h
  group Modules
    ./Modules/: MPUx_init.c MPU_DMP.c NRF_USART_MODULE.c NRF24L01.c PID_Control.c
  group Data_Process
    ./Math/: Data_Type_Conv.c mymath.c
  group INV_MPL
    ./core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./core/driver/stm32L/: log_stm32.c
    ./core/eMPL-hal/: eMPL_outputs.c
    ./core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./core/mpl/: libmpllib.lib
